# IAR project application_is.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8710C; __ARM_ARCH_8M_MAIN__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; __IEEE_LITTLE_ENDIAN; __ORDER_LITTLE_ENDIAN__; __BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__; FILE=void
  ICCARM.IExtraOptions: --cmse; --no_path_in_file_macros
  ICCARM.CCIncludePath2: inc; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\cmsis\rtl8710c\lib\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\fwlib\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\fwlib\lib\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\cmsis\cmsis-core\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\app\rtl_printf\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\app\shell; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\app\stdio_port; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\misc\utilities\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\os\freertos; ..\..\..\..\lib\FreeRTOS\portable\IAR\ARM_RTL8710C; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\api; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\api\at_cmd; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\api\platform; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\api\wifi; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\api\network\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\application; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\application\mqtt\MQTTClient; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\example; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\file_system; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\file_system\dct; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\utilities; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\mbed\hal; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\mbed\hal_ext; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\mbed\targets\hal\rtl8710c; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\mbed-drivers\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\os\os_dep\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\network; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\network\coap\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\..\lib\third_party\lwip\src\include; ..\..\..\..\lib\third_party\lwip\src\include\lwip; ..\..\..\..\lib\third_party\lwip\src\portable\realtek; ..\..\..\..\lib\third_party\lwip\src\portable\realtek\freertos; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\drivers\wlan\realtek\include; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\mbed\targets\hal\rtl8710c; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\test; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\inc; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\board\amebaz2\lib; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\board\amebaz2\src; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\board\amebaz2\src\data_uart; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\board\amebaz2\src\hci; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\board\amebaz2\src\os; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\misc\platform; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\misc\driver; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\misc\os; ..\..\..\..\lib\third_party\mbedtls\include; ..\..\..\..\lib\include; ..\..\..\..\lib\include\private; ..\..\..\..\demos\realtek\amebaz2\common\config_files; ..\..\..\..\lib\third_party\mbedtls\include; ..\..\..\..\demos\common\include; ..\..\..\..\lib\third_party\jsmn; ..\..\..\..\lib\third_party\tinycbor; ..\..\..\..\lib\ota\portable\realtek\ameba; ..\..\..\..\lib\third_party\pkcs11; ..\..\..\..\lib\FreeRTOS-Plus-TCP\include; ..\..\..\..\lib\FreeRTOS-Plus-TCP\source\portable\Compiler\IAR; ..\..\..\..\lib\FreeRTOS-Plus-TCP\source\protocols\include; ..\..\..\..\lib\third_party\unity\extras\fixture\src; ..\..\..\..\lib\third_party\unity\src; ..\..\..\common\cert_provision\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: V8M_STKOVF
  AARM.AUserIncludes: inc; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\cmsis; ..\..\..\..\lib\third_party\mcu_vendor\realtek\component\os\os_dep\include; ..\..\..\..\lib\FreeRTOS\portable\IAR\ARM_RTL8710C
  OBJCOPY.OOCOutputFile: application_is.srec
  prebuild: CSCRIPT  "..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\misc\iar_utility\prebuild.vbs" "$PROJ_DIR$"
  postbuild: CSCRIPT  "..\..\..\..\lib\third_party\mcu_vendor\realtek\component\soc\realtek\8710c\misc\iar_utility\postbuild_is.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: ram_start
  ILINK.IlinkIcfFile: application_is.icf
  ILINK.IlinkExtraOptions: --redirect malloc=__wrap_malloc; --redirect realloc=__wrap_realloc; --redirect free=__wrap_free; --redirect printf=__wrap_printf; --redirect sprintf=__wrap_sprintf; --redirect snprintf=__wrap_snprintf; --redirect vsnprintf=__wrap_vsnprintf; --redirect memcmp=__wrap_memcmp; --redirect memcpy=__wrap_memcpy; --redirect memmove=__wrap_memmove; --redirect memset=__wrap_memset; --redirect strcat=__wrap_strcat; --redirect strchr=__wrap_strchr; --redirect strcmp=__wrap_strcmp; --redirect strncmp=__wrap_strncmp; --redirect strnicmp=__wrap_strnicmp; --redirect strcpy=__wrap_strcpy; --redirect strncpy=__wrap_strncpy; --redirect strlcpy=__wrap_strlcpy; --redirect strlen=__wrap_strlen; --redirect strnlen=__wrap_strnlen; --redirect strncat=__wrap_strncat; --redirect strpbrk=__wrap_strpbrk; --redirect strspn=__wrap_strspn; --redirect strstr=__wrap_strstr; --redirect strtok=__wrap_strtok; --redirect strxfrm=__wrap_strxfrm; --redirect strsep=__wrap_strsep; --redirect strtod=__wrap_strtod; --redirect strtof=__wrap_strtof; --redirect strtold=__wrap_strtold; --redirect strtoll=__wrap_strtoll; --redirect strtoul=__wrap_strtoul; --redirect strtoull=__wrap_strtoull; --redirect atoi=__wrap_atoi; --redirect atoui=__wrap_atoui; --redirect atol=__wrap_atol; --redirect atoul=__wrap_atoul; --redirect atoull=__wrap_atoull; --redirect atof=__wrap_atof; --skip_dynamic_initialization
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group @SRAM
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/mbed/targets/hal/rtl8710c/: flash_api.c
    ../../../../lib/third_party/mcu_vendor/realtek/component/soc/realtek/8710c/misc/driver/: flash_api_ext.c
    ../../../../lib/third_party/mcu_vendor/realtek/component/soc/realtek/8710c/fwlib/source/ram_ns/: hal_flash.c hal_spic.c
  group amazon/demos
    ../common/application_code/: aws_main.c
  group amazon/demos/common/demo_runner
    ../../../common/demo_runner/: aws_demo_runner.c
    ../../../common/mqtt/: aws_subscribe_publish_loop.c
  group amazon/demos/common/devmode_key_provisioning
    ../../../common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group amazon/demos/common/greengrass_connectivity
    ../../../common/greengrass_connectivity/: aws_greengrass_discovery_demo.c
  group amazon/demos/common/logging
    ../../../common/logging/: aws_logging_task_dynamic_buffers.c
  group amazon/demos/common/mqtt
    ../../../common/mqtt/: aws_hello_world.c
  group amazon/demos/common/ota
    ../../../common/ota/: aws_ota_update_demo.c
  group amazon/demos/common/shadow
    ../../../common/shadow/: aws_shadow_lightbulb_on_off.c
  group amazon/demos/common/tcp
    ../../../common/tcp/: aws_simple_tcp_echo_server.c aws_tcp_echo_client_separate_tasks.c aws_tcp_echo_client_single_task.c
  group amazon/lib/bufferpool
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group amazon/lib/crypto
    ../../../../lib/crypto/: aws_crypto.c
  group amazon/lib/greengrass
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group amazon/lib/mqtt
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group amazon/lib/ota
    ../../../../lib/ota/: aws_ota_agent.c aws_ota_cbor.c
  group amazon/lib/ota/portable
    ../../../../lib/ota/portable/realtek/ameba/: aws_ota_pal.c aws_ota_rtl8710b.c
  group amazon/lib/pkcs11/mbedtls
    ../../../../lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
  group amazon/lib/pkcs11/portable
    ../../../../lib/pkcs11/portable/realtek/ameba/: aws_pkcs11_pal.c
  group amazon/lib/secure_sockets
    ../../../../lib/secure_sockets/portable/realtek/ameba/: aws_secure_sockets.c
  group amazon/lib/shadow
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group amazon/lib/third_party/jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c
  group amazon/lib/third_party/mbedtls
    ../../../../lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group amazon/lib/third_party/tinycbor
    ../../../../lib/third_party/tinycbor/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c
  group amazon/lib/third_party/unity
    ../../../../lib/third_party/unity/src/: unity.c
    ../../../../lib/third_party/unity/extras/fixture/src/: unity_fixture.c
  group amazon/lib/tls
    ../../../../lib/tls/: aws_tls.c
  group amazon/lib/utils
    ../../../../lib/utils/: aws_system_init.c
  group amazon/lib/wifi
    ../../../../lib/wifi/portable/realtek/ameba/: aws_wifi.c
  group cmsis
    ../../../../lib/third_party/mcu_vendor/realtek/component/soc/realtek/8710c/cmsis/rtl8710c/source/ram_s/: app_start.c
    ../../../../lib/third_party/mcu_vendor/realtek/component/soc/realtek/8710c/misc/utilities/source/ram/: libc_wrap.c
    ../../../../lib/third_party/mcu_vendor/realtek/component/soc/realtek/8710c/cmsis/rtl8710c/source/ram/: mpu_config.c
  group console
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/api/at_cmd/: atcmd_wifi.c
    ../../../../lib/third_party/mcu_vendor/realtek/component/soc/realtek/8710c/app/shell/: cmd_shell.c
  group lib
    ../../../../lib/third_party/mcu_vendor/realtek/component/soc/realtek/8710c/misc/bsp/lib/common/IAR/: lib_soc_is.a lib_wlan.a
  group network/api
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/api/: lwip_netconf.c
  group network/api/wifi
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_util.c
  group network/api/wifi/rtw_wpa_supplicant
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c
  group network/app
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/api/network/src/: wlan_network.c
  group network/lwip
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/network/dhcp/: dhcps.c
  group network/lwip/api
    ../../../../lib/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/core
    ../../../../lib/third_party/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group network/lwip/core/ipv4
    ../../../../lib/third_party/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group network/lwip/core/ipv6
    ../../../../lib/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group network/lwip/netif
    ../../../../lib/third_party/lwip/src/netif/: ethernet.c
  group network/lwip/port
    ../../../../lib/third_party/lwip/src/portable/realtek/freertos/: ethernetif.c sys_arch.c
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group os
    ../../../../lib/third_party/mcu_vendor/realtek/component/os/freertos/: cmsis_os.c freertos_cb.c freertos_service.c
    ../../../../lib/third_party/mcu_vendor/realtek/component/os/os_dep/: device_lock.c osdep_service.c
  group os/freertos
    ../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group os/freertos/portable
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_5.c
    ../../../../lib/FreeRTOS/portable/IAR/ARM_RTL8710C/: heap_rtk.c port.c portasm.s
  group peripheral/api
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/mbed/targets/hal/rtl8710c/: gpio_api.c timer_api.c wait_api.c wdt_api.c
  group peripheral/hal
    ../../../../lib/third_party/mcu_vendor/realtek/component/soc/realtek/8710c/fwlib/source/ram_s/: hal_efuse.c
    ../../../../lib/third_party/mcu_vendor/realtek/component/soc/realtek/8710c/fwlib/source/ram/: hal_misc.c hal_uart.c
  group user
    src/: main.c
  group cert_provision
    ../../../common/cert_provision/src/: cert_provision.c
  group utilities/example
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/example/amazon_freertos/: example_amazon_freertos.c
    ../../../../lib/third_party/mcu_vendor/realtek/component/common/example/: example_entry.c
